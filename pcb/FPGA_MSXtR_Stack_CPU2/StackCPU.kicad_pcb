# Repository PanykSystem/FPGA_MSXtR (continued)

## KiCad design pcb/FPGA_MSXtR_Stack_V9968/StackV9968.kicad_pcb (continued)

Board: 2 copper layers, 95.0 x 95.0 mm, 11 parts (0 on the bottom side), 32 nets.

Other parts of the board:
G1: LOGO; msx_logo
G2: LOGO; usa

File pcb/FPGA_MSXtR_Stack_V9968/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,SMD1210,1,100uF,C49066
C2,SMD0402,1,0.1uF,C1525
C3,SMD0805,1,15pF,C63339
U1,SMD3225,1,14.31818MHz,C252335

## KiCad design pcb/FPGA_MSXtR_Portable_Keyboard/FPGA_MSXtR_Portable_Keyboard.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF; C_0603_1608Metric
D1, D2, D3: LED; D_0805_2012Metric
IC1: FPGA_MSXtR_Portable_Keyboard; QFP50P900X900X160-48N
J1: ST-LINK; PinSocket_1x06_P2.54mm_Vertical
J2: groove; HW4-2.0-90D
R9, R10, R11, R16, R17: 3.3K; R_0805_2012Metric
R12, R13: 150; R_0805_2012Metric
R14, R15: 10K; R_0805_2012Metric
SW1: KEY_0; Tact_SW
SW2: KEY_1; Tact_SW
SW3: KEY_2; Tact_SW
SW4: KEY_3; Tact_SW
SW5: KEY_4; Tact_SW
SW6: KEY_5; Tact_SW
SW7: KEY_6; Tact_SW
SW8: KEY_7; Tact_SW
SW9: KEY_8; Tact_SW
SW10: KEY_9; Tact_SW
SW11: KEY_MINUS; Tact_SW
SW12: KEY_HAT; Tact_SW
SW13: KEY_YEN; Tact_SW
SW14: KEY_AT; Tact_SW
SW15: KEY_BRACE_L; Tact_SW
SW16: KEY_SEMI; Tact_SW
SW17: KEY_COLON; Tact_SW
SW18: KEY_BRACE_R; Tact_SW
SW19: KEY_COMMA; Tact_SW
SW20: KEY_PERIOD; Tact_SW
SW21: KEY_SLASH; Tact_SW
SW22: KEY_UBAR; Tact_SW
SW23: KEY_A; Tact_SW
SW24: KEY_B; Tact_SW
SW25: KEY_C; Tact_SW
SW26: KEY_D; Tact_SW
SW27: KEY_E; Tact_SW
SW28: KEY_F; Tact_SW
SW29: KEY_G; Tact_SW
SW30: KEY_H; Tact_SW
SW31: KEY_I; Tact_SW
SW32: KEY_J; Tact_SW
SW33: KEY_K; Tact_SW
SW34: KEY_L; Tact_SW
SW35: KEY_M; Tact_SW
SW36: KEY_N; Tact_SW
SW37: KEY_O; Tact_SW
SW38: KEY_P; Tact_SW
SW39: KEY_Q; Tact_SW
SW40: KEY_R; Tact_SW
SW41: KEY_S; Tact_SW
SW42: KEY_T; Tact_SW
SW43: KEY_U; Tact_SW
SW44: KEY_V; Tact_SW
SW45: KEY_W; Tact_SW
SW46: KEY_X; Tact_SW
SW47: KEY_Y; Tact_SW
SW48: KEY_Z; Tact_SW
SW49: KEY_SHIFT; Tact_SW
SW50: KEY_CTRL; Tact_SW
SW51: KEY_GRAPH; Tact_SW
SW52: KEY_CAPS; Tact_SW
SW53: KEY_KANA; Tact_SW
SW54: KEY_F1; Tact_SW
SW55: KEY_F2; Tact_SW
SW56: KEY_F3; Tact_SW
SW57: KEY_F4; Tact_SW
SW58: KEY_F5; Tact_SW
SW59: KEY_ESC; Tact_SW
SW60: KEY_TAB; Tact_SW
SW61: KEY_STOP; Tact_SW
SW62: KEY_BS; Tact_SW
SW63: KEY_SELECT; Tact_SW
SW64: KEY_RETURN; Tact_SW
SW65: KEY_SPACE; Tact_SW
SW66: KEY_HOME; Tact_SW
SW67: KEY_INS; Tact_SW
SW68: KEY_DEL; Tact_SW
SW69: KEY_LEFT; Tact_SW
SW70: KEY_UP; Tact_SW
SW71: KEY_DOWN; Tact_SW
SW72: KEY_RIGHT; Tact_SW
SW73: KEY_MENU; Tact_SW

Connections:
+3V3: C1.1, C2.1, C3.1, D1.2 (A), D2.2 (A), D3.2 (A), IC1.4 (VBAT), IC1.5 (VREF+), IC1.6 (VDD/VDDA), J1.2, J2.3, R14.2, R15.1, R16.2, R17.2
GND: C1.2, C2.2, C3.2, C4.2, IC1.7 (VSS/VSSA), J1.4, J2.4, SW73.1
I2C_SCL: IC1.25 (PB13-I2C2_SCL), J2.1, R16.1
I2C_SDA: IC1.23 (PB11-I2C2_SDA), J2.2, R17.1
LED0: IC1.1 (PC13-LED0), R9.1
LED1: IC1.2 (PC14-OSC32_IN-LED1), R10.1
LED2: IC1.3 (PC15-OSC32_OUT-LED2), R11.1
MENU: IC1.38 (PD0-MENU), SW73.2
NRST: C4.1, IC1.10 (NRST), J1.1
unnamed: D1.1 (K), R9.2
unnamed: D2.1 (K), R10.2
unnamed: D3.1 (K), R11.2
unnamed: IC1.35 (PA13-SYS_SWDIO), R13.1, R15.2
unnamed: IC1.36 (PA14-BOOT0-SYS_SWCLK), R12.1, R14.1
SWCLK: J1.5, R12.2
SWDIO: J1.3, R13.2
X0: IC1.11 (PA0-X0), SW1.2, SW9.2, SW17.2, SW25.2, SW33.2, SW41.2, SW49.2, SW57.2, SW65.2
X1: IC1.12 (PA1-X1), SW2.2, SW10.2, SW18.2, SW26.2, SW34.2, SW42.2, SW50.2, SW58.2, SW66.2
X2: IC1.13 (PA2-X2), SW3.2, SW11.2, SW19.2, SW27.2, SW35.2, SW43.2, SW51.2, SW59.2, SW67.2
X3: IC1.14 (PA3-X3), SW4.2, SW12.2, SW20.2, SW28.2, SW36.2, SW44.2, SW52.2, SW60.2, SW68.2
X4: IC1.15 (PA4-X4), SW5.2, SW13.2, SW21.2, SW29.2, SW37.2, SW45.2, SW53.2, SW61.2, SW69.2
X5: IC1.16 (PA5-X5), SW6.2, SW14.2, SW22.2, SW30.2, SW38.2, SW46.2, SW54.2, SW62.2, SW70.2
X6: IC1.17 (PA6-X6), SW7.2, SW15.2, SW23.2, SW31.2, SW39.2, SW47.2, SW55.2, SW63.2, SW71.2
X7: IC1.18 (PA7-X7), SW8.2, SW16.2, SW24.2, SW32.2, SW40.2, SW48.2, SW56.2, SW64.2, SW72.2
Y0: IC1.19 (PB0-Y0), SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1
Y1: IC1.20 (PB1-Y1), SW9.1, SW10.1, SW11.1, SW12.1, SW13.1, SW14.1, SW15.1, SW16.1
Y2: IC1.21 (PB2-Y2), SW17.1, SW18.1, SW19.1, SW20.1, SW21.1, SW22.1, SW23.1, SW24.1
Y3: IC1.42 (PB3-Y3), SW25.1, SW26.1, SW27.1, SW28.1, SW29.1, SW30.1, SW31.1, SW32.1
Y4: IC1.43 (PB4-Y4), SW33.1, SW34.1, SW35.1, SW36.1, SW37.1, SW38.1, SW39.1, SW40.1
Y5: IC1.44 (PB5-Y5), SW41.1, SW42.1, SW43.1, SW44.1, SW45.1, SW46.1, SW47.1, SW48.1
Y6: IC1.45 (PB6-Y6), SW49.1, SW50.1, SW51.1, SW52.1, SW53.1, SW54.1, SW55.1, SW56.1
Y7: IC1.46 (PB7-Y7), SW57.1, SW58.1, SW59.1, SW60.1, SW61.1, SW62.1, SW63.1, SW64.1
Y8: IC1.47 (PB8-Y8), SW65.1, SW66.1, SW67.1, SW68.1, SW69.1, SW70.1, SW71.1, SW72.1

Notes on the sheet:
5Vを出すM5Stack等は接続禁止。3V3をつなげてください。

Board: 2 copper layers, 95.0 x 95.0 mm, 98 parts (0 on the bottom side), 33 nets.

Other parts of the board:
G1: LOGO; usa_10x7
G2: LOGO; msx_logo_15x5p8
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3_ISO14580

File pcb/FPGA_MSXtR_Portable_Keyboard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4",0603,4,0.1uF,
"D1, D2, D3",0805,3,LED,
IC1,QFP50P900X900X160-48N,1,FPGA_MSXtR_Portable_Keyboard,
J1,PinSocket_1x06_P2.54mm_Vertical,1,ST-LINK,
J2,HW4-2.0-90D,1,groove,
"R10, R11, R16, R17, R9",0805,5,3.3K,
"R12, R13",0805,2,150,
"R14, R15",0805,2,10K,
SW1,Tact_SW,1,KEY_0,
SW10,Tact_SW,1,KEY_9,
SW11,Tact_SW,1,KEY_MINUS,
SW12,Tact_SW,1,KEY_HAT,
SW13,Tact_SW,1,KEY_YEN,
SW14,Tact_SW,1,KEY_AT,
SW15,Tact_SW,1,KEY_BRACE_L,
SW16,Tact_SW,1,KEY_SEMI,
SW17,Tact_SW,1,KEY_COLON,
SW18,Tact_SW,1,KEY_BRACE_R,
SW19,Tact_SW,1,KEY_COMMA,
SW2,Tact_SW,1,KEY_1,
SW20,Tact_SW,1,KEY_PERIOD,
SW21,Tact_SW,1,KEY_SLASH,
SW22,Tact_SW,1,KEY_UBAR,
SW23,Tact_SW,1,KEY_A,
SW24,Tact_SW,1,KEY_B,
SW25,Tact_SW,1,KEY_C,
SW26,Tact_SW,1,KEY_D,
SW27,Tact_SW,1,KEY_E,
SW28,Tact_SW,1,KEY_F,
SW29,Tact_SW,1,KEY_G,
SW3,Tact_SW,1,KEY_2,
SW30,Tact_SW,1,KEY_H,
SW31,Tact_SW,1,KEY_I,
SW32,Tact_SW,1,KEY_J,
SW33,Tact_SW,1,KEY_K,
SW34,Tact_SW,1,KEY_L,
SW35,Tact_SW,1,KEY_M,
SW36,Tact_SW,1,KEY_N,
SW37,Tact_SW,1,KEY_O,
SW38,Tact_SW,1,KEY_P,
SW39,Tact_SW,1,KEY_Q,
SW4,Tact_SW,1,KEY_3,
SW40,Tact_SW,1,KEY_R,
SW41,Tact_SW,1,KEY_S,
SW42,Tact_SW,1,KEY_T,
SW43,Tact_SW,1,KEY_U,
SW44,Tact_SW,1,KEY_V,
SW45,Tact_SW,1,KEY_W,
SW46,Tact_SW,1,KEY_X,
SW47,Tact_SW,1,KEY_Y,
SW48,Tact_SW,1,KEY_Z,
SW49,Tact_SW,1,KEY_SHIFT,
SW5,Tact_SW,1,KEY_4,
SW50,Tact_SW,1,KEY_CTRL,
SW51,Tact_SW,1,KEY_GRAPH,
SW52,Tact_SW,1,KEY_CAPS,
SW53,Tact_SW,1,KEY_KANA,
SW54,Tact_SW,1,KEY_F1,
SW55,Tact_SW,1,KEY_F2,
SW56,Tact_SW,1,KEY_F3,
SW57,Tact_SW,1,KEY_F4,
SW58,Tact_SW,1,KEY_F5,
SW59,Tact_SW,1,KEY_ESC,
SW6,Tact_SW,1,KEY_5,
SW60,Tact_SW,1,KEY_TAB,
SW61,Tact_SW,1,KEY_STOP,
SW62,Tact_SW,1,KEY_BS,
SW63,Tact_SW,1,KEY_SELECT,
SW64,Tact_SW,1,KEY_RETURN,
SW65,Tact_SW,1,KEY_SPACE,
SW66,Tact_SW,1,KEY_HOME,
SW67,Tact_SW,1,KEY_INS,
SW68,Tact_SW,1,KEY_DEL,
SW69,Tact_SW,1,KEY_LEFT,
SW7,Tact_SW,1,KEY_6,
SW70,Tact_SW,1,KEY_UP,
SW71,Tact_SW,1,KEY_DOWN,
SW72,Tact_SW,1,KEY_RIGHT,
SW73,Tact_SW,1,KEY_MENU,
SW8,Tact_SW,1,KEY_7,
SW9,Tact_SW,1,KEY_8,

## KiCad design pcb/FPGA_MSXtR_TangNano20Kx2/FPGA_MSXtR_TangNano20Kx2.kicad_pcb

Parts:
C1: 440uF; C_Radial_D5.0mm_H5.0mm_P2.00mm
C2, C4, C5: 0.1uF; C_0402_1005Metric
C3: 15pF; C_0402_1005Metric
D1: LED; LED_0805_2012Metric
J1: I/O Expander; PinHeader_2x08_P2.54mm_Vertical
J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J3: PICO_GPIO; PinHeader_2x12_P2.54mm_Vertical
R1: 330; R_0402_1005Metric
R2, R3: 5.1k; R_0402_1005Metric
R4, R5, R6, R7, R8, R9, R10, R11: 4.7k; R_0402_1005Metric
SW1, SW2: SW_SPDT; SlideSwitch
U1, U2: TangNano20K
U3: CLOCK
U4: RPi_Pico_SMD_TH
U5, U6: W25Q32JVSS; SOIC-8_5.3x5.3mm_P1.27mm
U7: USB-C Connector

Connections:
+3V3: C2.1, C4.2, C5.2, J1.10, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, U1.19 (3V3), U3.1 (En), U3.4 (3V3), U5.8 (VCC), U6.8 (VCC)
+5V: C1.1, J1.16, J2.5, J3.24, U1.40 (5V), U2.40 (5V), U4.39 (VSYS(+5V)), U7.A4 (VBUS), U7.A9 (VBUS), U7.B4 (VBUS), U7.B9 (VBUS)
ADC_REF: J3.19, U4.35 (ADC_REF)
CLOCK: C3.1, U1.38 (CLK14M(76)), U2.38 (CLK14M(76)), U3.3 (CLK)
DIO0: J1.1, U1.13 (DIO0(30))
DIO1: J1.2, U1.14 (DIO1(31))
DIO2: J1.3, U1.15 (DIO2(17))
DIO3: J1.4, U1.16 (DIO3(20))
DIO4: J1.5, U1.17 (DIO4(19))
DIO5: J1.6, U1.18 (DIO5(18))
DIO6: J1.7, U1.24 (DIO6(72))
DIO7: J1.8, U1.23 (DIO7(71))
FPGA_SPI_CLK: U2.16 (SPI_CLK(20)), U4.9 (FPGA_SPI_CLK(GP6))
FPGA_SPI_CS_N: R7.1, U2.15 (SPI_CS_N(17)), U4.7 (FPGA_SPI_CS_N(GP5))
FPGA_SPI_INTR: R11.1, U2.37 (SPI_INTR(80)), U4.5 (FPGA_SPI_INTR(GP3))
FPGA_SPI_MISO: U2.18 (SPI_MISO(18)), U4.6 (FPGA_SPI_MISO(GP4))
FPGA_SPI_MOSI: U2.17 (SPI_MOSI(19)), U4.10 (FPGA_SPI_MOSI(GP7))
GND: C1.2, C2.2, C3.2, C4.1, C5.1, J1.9, J2.6, J3.22, J3.23, R1.2, R2.1, R3.1, R4.1, SW1.3 (C), SW2.3 (C), U1.20 (GND), U1.26 (GND), U1.39 (GND), U2.20 (GND), U2.26 (GND), U2.39 (GND), U3.2 (GND), U4.3 (GND), U4.8 (GND), U4.13 (GND), U4.18 (GND), U4.23 (GND), U4.28 (GND), U4.33 (GND), U4.38 (GND), U5.4 (GND), U6.4 (GND), U7.A1 (GND), U7.A12 (GND), U7.B1 (GND), U7.B12 (GND), U7.SHELD (GND)
GP0: J3.1, U4.1 (GP0)
GP1: J3.2, U4.2 (GP1)
GP2: J3.3, U4.4 (GP2)
GP12: J3.4, U4.16 (GP12)
GP13: J3.5, U4.17 (GP13)
GP14: J3.6, U4.19 (GP14)
GP15: J3.7, U4.20 (GP15)
GP16: J3.8, U4.21 (GP16)
GP17: J3.9, U4.22 (GP17)
GP18: J3.10, U4.24 (GP18)
GP19: J3.11, U4.25 (GP19)
GP20: J3.12, U4.26 (GP20)
GP21: J3.13, U4.27 (GP21)
GP22: J3.14, U4.29 (GP22)
GP26: J3.15, U4.31 (GP26)
GP27: J3.16, U4.32 (GP27)
GP28: J3.17, U4.34 (GP28)
I2S_BCLK: U1.34 (I2S_BCLK(56)), U2.34 (I2S_BCLK(56))
I2S_D: U1.33 (I2S_DOUT(54)), U2.33 (I2S_DIN(54))
I2S_LRCK: U1.30 (I2S_LRCK(55)), U2.30 (I2S_LRCK(55))
INTR: R10.1, U1.21 (INTR(52)), U2.28 (INTR(86))
IO_CLK: J1.11, R5.1, U1.28 (IO_CLK(86))
IO_SEL0: J1.15, U1.37 (IO_SEL2(80))
IO_SEL1: J1.14, U1.36 (IO_SEL1(42))
IO_SEL2: J1.13, U1.35 (IO_SEL0(41))
unnamed: D1.2 (A), U2.23 (LED(71))
unnamed: D1.1 (K), R1.1
unnamed: SW1.2 (B), U1.31 (DIPSW(48))
unnamed: SW2.2 (B), U2.24 (DIPSW(72))
unnamed: R2.2, U7.A5 (CC1)
unnamed: R3.2, U7.B5 (CC2)
PICO_3V3: J3.20, U4.36 (3V3)
PICO_3V3_EN: J3.21, U4.37 (3V3_EN)
RESET_N: J1.12, R4.2, U1.29 (RESET_N(49))
RUN: J3.18, U4.30 (RUN)
SD_SPI_CLK: J2.2, U4.14 (SD_SPI_SCK(GP10))
SD_SPI_CS_N: J2.1, R6.1, U4.12 (SD_SPI_CS_N(GP9))
SD_SPI_MISO: J2.4, U4.11 (SD_SPI_MISO(GP8))
SD_SPI_MOSI: J2.3, U4.15 (SD_SPI_MOSI(GP11))
SROM2_CS_N: R9.1, U1.22 (SROM2_CS_N(53)), U6.1 (~CS)
SROM_CLK: U1.11 (SROM_CLK(26)), U5.6 (CLK), U6.6 (CLK)
SROM_CS_N: R8.1, U1.12 (SROM_CS_N(29)), U5.1 (~CS)
SROM_SDIO0: U1.7 (SROM_SIO0(16)), U5.5 (DI/IO_{0}), U6.5 (DI/IO_{0})
SROM_SDIO1: U1.8 (SROM_SIO1(27)), U5.2 (DO/IO_{1}), U6.2 (DO/IO_{1})
SROM_SDIO2: U1.9 (SROM_SIO2(28)), U5.3 (~WP/IO_{2}), U6.3 (~WP/IO_{2})
SROM_SDIO3: U1.10 (SROM_SIO3(25)), U5.7 (~HOLD/~RESET/IO_{3}), U6.7 (~HOLD/~RESET/IO_{3})
VDP_SI0: U1.5 (VDP_SI0(77)), U2.2 (VDP_SO0(74))
VDP_SI1: U1.6 (VDP_SI1(15)), U2.3 (VDP_SO1(75))
VDP_SI_CLK: U1.4 (VDP_SI_CLK(85)), U2.1 (VDP_SO_CLK(73))
VDP_SO0: U1.2 (VDP_SO0(74)), U2.6 (VDP_SI0(15))
VDP_SO1: U1.3 (VDP_SO1(75)), U2.7 (VDP_SI1(16))
VDP_SO_CLK: U1.1 (VDP_SO_CLK(73)), U2.4 (VDP_SI_CLK(85))

Notes on the sheet:
OptionROM
En は、OPEN か H で CLK を出力、L で CLK が HiZ になる。
14.318180MHz
DIO, IO_SEL 共に 3V3 のデジタル信号
System ROM (BIOS/DOS/Kanji)

Board: 2 copper layers, 95.0 x 95.0 mm, 35 parts (0 on the bottom side), 70 nets.

Other parts of the board:
G1: LOGO; usa_10x7
G2: LOGO; msx_logo_15x5p8
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3

File pcb/FPGA_MSXtR_TangNano20Kx2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C2, C4, C5",0402,3,0.1uF,C1525
C3,0402,1,15pF,C1548
D1,0805,1,LED,C2293
R1,0402,1,330,C12246
"R10, R11, R4, R5, R6, R7, R8, R9",0402,8,4.7k,C25905
"R2, R3",0402,2,5.1k,C25900
U3,14.31818MHz,1,SMD3225-4P,C252335
"U5, U6",SOIC-8_5.3x5.3mm_P1.27mm,2,W25Q32JVSS,C82344

## Code that names these connections

File keyboard/MSXtR_Portable_Keyboard/MSXtR_Portable_Keyboard.ioc (part):

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Mcu.Name=STM32G0B0CETx
Mcu.Package=LQFP48
Mcu.UserName=STM32G0B0CETx
PA0.GPIOParameters=GPIO_PuPd,GPIO_Label
PA0.GPIO_Label=X0
PA0.GPIO_PuPd=GPIO_PULLUP
PA0.Signal=GPIO_Input
PA1.GPIOParameters=GPIO_PuPd,GPIO_Label
PA1.GPIO_Label=X1
PA1.GPIO_PuPd=GPIO_PULLUP
PA1.Signal=GPIO_Input
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14-BOOT0.Mode=Serial_Wire
PA14-BOOT0.Signal=SYS_SWCLK
PA2.GPIOParameters=GPIO_PuPd,GPIO_Label
PA2.GPIO_Label=X2
PA2.GPIO_PuPd=GPIO_PULLUP
PA2.Signal=GPIO_Input
PA3.GPIOParameters=GPIO_PuPd,GPIO_Label
PA3.GPIO_Label=X3
PA3.GPIO_PuPd=GPIO_PULLUP
PA3.Signal=GPIO_Input
PA4.GPIOParameters=GPIO_PuPd,GPIO_Label
PA4.GPIO_Label=X4
PA4.GPIO_PuPd=GPIO_PULLUP
PA4.Signal=GPIO_Input
PA5.GPIOParameters=GPIO_PuPd,GPIO_Label
PA5.GPIO_Label=X5
PA5.GPIO_PuPd=GPIO_PULLUP
PA5.Signal=GPIO_Input
PA6.GPIOParameters=GPIO_PuPd,GPIO_Label
PA6.GPIO_Label=X6
PA6.GPIO_PuPd=GPIO_PULLUP
PA6.Signal=GPIO_Input
PA7.GPIOParameters=GPIO_PuPd,GPIO_Label
PA7.GPIO_Label=X7
PA7.GPIO_PuPd=GPIO_PULLUP
PA7.Signal=GPIO_Input
PB0.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB0.GPIO_Label=Y0
PB0.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB0.GPIO_PuPd=GPIO_NOPULL
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB1.GPIO_Label=Y1
PB1.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB1.GPIO_PuPd=GPIO_NOPULL
PB1.Signal=GPIO_Output
PB10.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB10.GPIO_Label=Y10
PB10.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB10.GPIO_PuPd=GPIO_NOPULL
PB10.Signal=GPIO_Output
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB13.Mode=I2C
PB13.Signal=I2C2_SCL
PB2.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB2.GPIO_Label=Y2
PB2.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB2.GPIO_PuPd=GPIO_NOPULL
PB2.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB3.GPIO_Label=Y3
PB3.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB3.GPIO_PuPd=GPIO_NOPULL
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB4.GPIO_Label=Y4
PB4.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB4.GPIO_PuPd=GPIO_NOPULL
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB5.GPIO_Label=Y5
PB5.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB5.GPIO_PuPd=GPIO_NOPULL
PB5.Signal=GPIO_Output
PB6.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB6.GPIO_Label=Y6
PB6.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB6.GPIO_PuPd=GPIO_NOPULL
PB6.Signal=GPIO_Output
PB7.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB7.GPIO_Label=Y7
PB7.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB7.GPIO_PuPd=GPIO_NOPULL
PB7.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB8.GPIO_Label=Y8
PB8.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB8.GPIO_PuPd=GPIO_NOPULL
PB8.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB9.GPIO_Label=Y9
PB9.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB9.GPIO_PuPd=GPIO_NOPULL
PB9.Signal=GPIO_Output
PC13.GPIOParameters=PinState,GPIO_Label
PC13.GPIO_Label=LED0
PC13.PinState=GPIO_PIN_SET
PC13.Signal=GPIO_Output
PC14-OSC32_IN\ (PC14).GPIOParameters=PinState,GPIO_Label
PC14-OSC32_IN\ (PC14).GPIO_Label=LED1
PC14-OSC32_IN\ (PC14).PinState=GPIO_PIN_SET
PC14-OSC32_IN\ (PC14).Signal=GPIO_Output
PC15-OSC32_OUT\ (PC15).GPIOParameters=PinState,GPIO_Label
PC15-OSC32_OUT\ (PC15).GPIO_Label=LED2
PC15-OSC32_OUT\ (PC15).PinState=GPIO_PIN_SET
PC15-OSC32_OUT\ (PC15).Signal=GPIO_Output
PD0.GPIOParameters=GPIO_PuPd,GPIO_Label
PD0.GPIO_Label=MENU
PD0.GPIO_PuPd=GPIO_PULLUP
PD0.Signal=GPIO_Input
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-04-04 MSXtR TangNano20K ピンアサイン表を追加
2026-04-04 MSXtR TangNano20K 2個バージョンの PCBデザイン追加(未確認)
2026-04-06 FPGA-PICOプロトコルのドキュメントを追加
2026-04-06 UARTテストを追加
2026-04-07 uart を修正
2026-04-09 cz80 + BOOT ROM + UART で動作した実験回路
2026-04-09 FPGA MSXtR TangNano20K 2個バージョン (動作未確認) の PCBデータ
2026-04-11 TEST MESSAGE 送信動作確認完了
2026-04-11 bootrom: 初期化時にff_rom_qを0に設定
2026-04-14 VDP側のテスト回路 青色LED点滅
2026-04-19 FPGA MSXtR: 更新されたTangFPGAピン配置のExcelファイル
2026-04-19 bootrom: スタックポインタの初期化値を修正し、関連するログを更新 設定ファイルのパスを修正し、RTLパーサーの引数を更新
2026-04-19 cz80, cr800 切り替え動作完了。SRAM はなぜか奇数アドレスの読み書きができない（EDAツールのバグ？）ので、暫定的に偶数アドレスだけ利用するようにして回避。
2026-04-20 CPUサイドTangNanoテスト回路
2026-04-20 VDPサイドTangNanoテスト回路
2026-04-20 VDP側TangNano で cz80+UART 動作確認完了
2026-04-21 ModelSIMシミュレーションと、GOWIN EDA でビルドが通るようになったもの。動作未確認。
2026-04-24 ビルドが通るようになった。しかし、DVI出力が出ない。
2026-04-24 14.31818MHz を源振として DVI 出力が出ることを確認するテスト
2026-04-25 cz80 と v9968 組み込んでみたがうまく表示が出ない、ボツ
2026-04-25 V9968 Cartridge をベースにしたところ、表示が出るようになった
2026-04-26 cz80 と v9968 を 1つの TangNano20K に収めるとタイミング収束しないことを確認。ボツ。
2026-04-26 readme.md 追加
2026-04-26 006 から cz80, BOOT ROM/RAM だけ削除したところリセットの一部以外のタイミング割れが解消。
2026-05-03 .editorconfig, .gitattributes, and .gitignore files updated for improved text file handling and additional ignored patterns
2026-05-03 Portable Keyboard の PCB とファームウェアプロジェクトファイル（まだ空）を追加
2026-05-16 コントローラーとなる RasPiPico2W のファームウェア（ビルドが通ったレベル）
2026-05-16 ピンアサイン更新
2026-05-16 I2Cキーボードコントローラーのファームウェア。STM32。
2026-05-17 SMDなタクトスイッチがスルーホール設定になっていたミスを修正
2026-05-17 STM32側の I2C の割り込み設定が足りていなかったバグを修正
2026-05-17 MENUキーを Y11 に出現させるコードを追加。 コントローラー側から要求が来てからキーマトリクスを更新して返答する動作に変更。
2026-05-17 コードリファクタ、SPI初期化追加、マルチコア動作追加。
    コードリファクタ、SPI初期化追加、マルチコア動作追加。
2026-05-26 コードリファクタ、SPI初期化追加、マルチコア動作追加。
2026-05-26 Copilot用の指示書を追加
2026-05-29 SPI経由でFPGAのUARTに文字列を出力する処理を追加。
2026-05-29 CMakeファイルに依存関係と生成物の情報を追加
2026-05-29 SPIのバグを修正
2026-05-29 SPI 80MHz で通信を確立した。
2026-05-29 pico2w を pico2w_labl_vdp007 に改名。ついでにリファクタリング。
2026-05-29 .d を除外対象に追加
2026-05-30 font.bin 追加
2026-05-30 キーマトリクスを VDP表示画面に出すように修正。
2026-06-04 Removed
2026-06-06 液晶表示のための実験回路
2026-06-07 タイミング・setup/hold のエラーを解消。
2026-06-07 Modified
2026-06-07 液晶パネルに表示が出た記念
2026-06-07 タイミングバイオレーション修正
2026-06-30 SPI FPGA-->Pico (Read Access) Succeeded
