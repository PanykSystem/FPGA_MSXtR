# Repository PanykSystem/FPGA_MSXtR

## KiCad design pcb/FPGA_MSXtR_Stack_CPU2/StackCPU.kicad_pcb

Board: 2 copper layers, 95.0 x 95.0 mm, 58 parts (0 on the bottom side), 93 nets.

Parts:
C1, C3, C4, C5, C6, C9, C10, C11, C13: 0.1uF; C_0402_1005Metric
C2: 15pF; C_0805_2012Metric
C7: 100uF; C_1210_3225Metric
C8: 1uF; C_0402_1005Metric
C12: 470uF; Capacitor(C453487)
G1: LOGO; msx_logo
G2: LOGO; usa
J1: MSX_EXBUS_A; PinHeader_2x20_P2.54mm_Vertical
J2: MSX_EXBUS_B; PinHeader_2x20_P2.54mm_Vertical
J3: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J4: Micro_SD_Card; MicroSD(C91145)
J5: Keybard I2C Connector; Grove_I2C
J6: USB_C_Receptacle_PowerOnly_6P; USB-C(C2927029)
R1, R2: 5.1K; R_0603_1608Metric
R3, R4, R5, R6: 22K; R_0402_1005Metric
R7, R8, R9, R10, R11, R12, R15, R16, R17, R18, R19, R20, R21, R22: 3.3K; R_0402_1005Metric
R13, R14: 100K; R_0402_1005Metric
SW1: SW_MEC_5G; SideSW(C963235)
SW2: SW_SPDT; Slide SW(C7431058)
SW3: SW_DIP_x04; DipSW4(C129043)
U1: TangPrimer25K(UPPER)
U2: TangPrimer25K(LOWER)
U3: CLOCK
U4: RaspberryPiPico2W
U5, U6, U7, U8: QSPI-SRAM 4Mbit (8SOIC)
U9: DCDC_MAU108
U10: W25Q32JVSS; SOIC-8_5.3x5.3mm_P1.27mm
U11, U12: TSOP-I-32_11.8x8mm_P0.5mm

Connections:
+3V3: C1.1, C3.1, C4.1, C5.1, C6.1, C9.2, C10.1, C11.1, C13.1, J2.35, J4.4 (VDD), J5.3, R3.2, R4.2, R5.2, R6.2, R7.1, R8.1, R9.1, R10.1, R11.2, R12.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, U1.2 (VCCIO2/3), U1.4 (VCCIO2/3), U1.46 (VDD_3V3), U1.48 (VDD_3V3), U1.50 (VDD_3V3), U2.84 (VCCIO0/1), U2.86 (VCCIO0/1), U2.89 (VCCIO6/7), U2.91 (VCCIO6/7), U3.1 (En), U3.4 (3V3), U5.8 (VCC), U6.8 (VCC), U7.8 (VCC), U8.8 (VCC), U10.3 (~WP/IO_{2}), U10.7 (~HOLD/~RESET/IO_{3}), U10.8 (VCC), U11.8 (VCC), U12.8 (VCC)
+5V: C7.1, C8.1, C12.1, J1.34, J2.39, J3.4, SW2.2 (B), U1.52 (VDD_5V), U1.54 (VDD_5V), U1.56 (VDD_5V), U1.58 (VDD_5V), U1.60 (VDD_5V), U4.40 (VBUS), U9.1 (+5V)
+12V: J1.38, R13.2, U9.6 (+12V)
-12V: J1.40, R14.1, U9.4 (-12V)
CLK28M: C2.1, U2.64 (CLK28M), U3.3 (CLK)
DIPSW0: SW3.1, U4.25 (GP19)
DIPSW1: SW3.2, U4.24 (GP18)
DIPSW2: SW3.3, U4.22 (GP17)
DIPSW3: SW3.4, U4.21 (GP16)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, J1.36, J2.37, J2.40, J3.1, J3.2, J4.6 (VSS), J5.4, J6.A12 (GND), R1.2, R2.2, R13.1, R14.2, SW1.3 (B), SW3.5, SW3.6, SW3.7, SW3.8, U1.1 (GND), U1.19 (GND), U1.29 (GND), U1.35 (GND), U1.41 (GND), U1.47 (GND), U1.53 (GND), U1.59 (GND), U2.61 (GND), U2.62 (GND), U2.75 (GND), U2.87 (GND), U2.88 (GND), U2.105 (GND), U2.110 (GND), U2.119 (GND), U2.120 (GND), U3.2 (GND), U4.8 (GND), U4.13 (GND), U4.18 (GND), U4.23 (GND), U4.28 (GND), U4.33 (GND), U4.38 (GND), U5.4 (VSS), U6.4 (VSS), U7.4 (VSS), U8.4 (VSS), U9.2 (GND), U9.5 (COMMON), U10.4 (GND), U11.24 (GND), U12.24 (GND)
I2C_SCL: J5.2, U4.27 (GP21)
I2C_SDA: J5.1, U4.26 (GP20)
JTAG_TCK: J3.6, U1.21 (JTAG_TCK)
JTAG_TDI: J3.8, U1.27 (JTAG_TDI)
JTAG_TDO: J3.10, U1.25 (JTAG_TDO)
JTAG_TMS: J3.12, U1.23 (JTAG_TMS)
MCU_CS_N: U1.14 (MCU_CS_N), U4.7 (FPGA_SPI_CS_N(GP5))
MCU_INTR: U2.83 (MCU_INTR), U4.5 (FPGA_SPI_INTR(GP3))
MCU_MISO: U1.20 (MCU_MISO), U4.6 (FPGA_SPI_MISO(GP4))
MCU_MOSI: U1.18 (MCU_MOSI), U4.10 (FPGA_SPI_MOSI(GP7))
MCU_SCLK: U1.16 (MCU_SCLK), U4.9 (FPGA_SPI_CLK(GP6))
unnamed: J6.A5 (CC1), R1.1
unnamed: J6.B5 (CC2), R2.1
unnamed: J6.A9 (VBUS), SW2.1 (A)
RESET_BUTTON: SW1.1 (A), U4.29 (GP22)
SD_SPI_CS_N: J4.2 (DAT3/CD), R3.1, U4.12 (SD_SPI_CS_N(GP9))
SD_SPI_MISO: J4.7 (DAT0), R6.1, U4.11 (SD_SPI_MISO(GP8))
SD_SPI_MOSI: J4.3 (CMD), R4.1, U4.15 (SD_SPI_MOSI(GP11))
SD_SPI_SCK: J4.5 (CLK), R5.1, U4.14 (SD_SPI_SCK(GP10))
SLOT_A0: J1.25, U2.63 (SLOT_A0), U11.20 (A0), U12.20 (A0)
SLOT_A1: J2.26, U2.65 (SLOT_A1), U11.19 (A1), U12.19 (A1)
SLOT_A2: J1.27, U2.67 (SLOT_A2), U11.18 (A2), U12.18 (A2)
SLOT_A3: J2.28, U2.69 (SLOT_A3), U11.17 (A3), U12.17 (A3)
SLOT_A4: J1.29, U2.71 (SLOT_A4), U11.16 (A4), U12.16 (A4)
SLOT_A5: J2.30, U2.73 (SLOT_A5), U11.15 (A5), U12.15 (A5)
SLOT_A6: J1.19, U2.93 (SLOT_A6), U11.14 (A6), U12.14 (A6)
SLOT_A7: J2.20, U2.95 (SLOT_A7), U11.13 (A7), U12.13 (A7)
SLOT_A8: J1.21, U2.82 (SLOT_A8), U11.3 (A8), U12.3 (A8)
SLOT_A9: J2.16, U2.80 (SLOT_A9), U11.2 (A9), U12.2 (A9)
SLOT_A10: J1.17, U2.78 (SLOT_A10), U11.31 (A10), U12.31 (A10)
SLOT_A11: J2.18, U2.76 (SLOT_A11), U11.1 (A11), U12.1 (A11)
SLOT_A12: J2.22, U2.74 (SLOT_A12), U11.12 (A12), U12.12 (A12)
SLOT_A13: J1.23, U2.72 (SLOT_A13), U11.4 (A13), U12.4 (A13)
SLOT_A14: J2.24, U2.108 (SLOT_A14), U11.5 (A14), U12.5 (A14)
SLOT_A15: J1.15, U2.106 (SLOT_A15), U11.11 (A15), U12.11 (A15)
SLOT_A16: U2.111 (SLOT_A16), U11.10 (A16), U12.10 (A16)
SLOT_A17: U2.113 (SLOT_A17), U11.6 (A17), U12.6 (A17)
SLOT_A18: U2.115 (SLOT_A18), U11.9 (A18), U12.9 (A18)
SLOT_BUSDIR_N: J1.9, U2.103 (SLOT_BUSDIR_N)
SLOT_CLOCK_N: J1.39, U2.77 (SLOT_CLOCK_N(READY))
SLOT_CS1_N: J2.2, U1.10 (SLOT_CS1_N)
SLOT_CS2_N: J1.1, U1.12 (SLOT_CS2_N)
SLOT_CS12_N: J2.4, U2.85 (SLOT_CS12_N(DONE))
SLOT_D0: J1.31, U2.90 (SLOT_D0), U11.21 (D0), U12.21 (D0)
SLOT_D1: J2.32, U2.92 (SLOT_D1), U11.22 (D1), U12.22 (D1)
SLOT_D2: J1.33, U2.94 (SLOT_D2), U11.23 (D2), U12.23 (D2)
SLOT_D3: J2.34, U2.96 (SLOT_D3), U11.25 (D3), U12.25 (D3)
SLOT_D4: J1.35, U2.98 (SLOT_D4), U11.26 (D4), U12.26 (D4)
SLOT_D5: J2.36, U2.100 (SLOT_D5), U11.27 (D5), U12.27 (D5)
SLOT_D6: J1.37, U2.102 (SLOT_D6), U11.28 (D6), U12.28 (D6)
SLOT_D7: J2.38, U2.104 (SLOT_D7), U11.29 (D7), U12.29 (D7)
SLOT_DATA_DIR: J2.5, U1.6 (SLOT_DATA_DIR)
SLOT_INT_N: J1.7, U2.97 (SLOT_INT_N)
SLOT_IORQ_N: J2.10, U2.68 (SLOT_IORQ_N)
SLOT_M1_N: J2.8, U1.3 (SLOT_M1_N)
SLOT_MERQ_N: J1.11, U2.70 (SLOT_MERQ_N)
SLOT_OE_N: J2.7, R7.2, U1.5 (SLOT_OE_N)
SLOT_RD_N: J1.13, U2.109 (SLOT_RD_N), U11.32 (/OE), U12.32 (/OE)
SLOT_RESET_N: J2.14, U2.101 (SLOT_RESET_N)
SLOT_RFSH_N: J1.2, U2.66 (SLOT_RFSH_N)
SLOT_ROM0_CE_N: U1.8 (SLOT_ROM0_CE_N), U11.30 (/CE)
SLOT_ROM1_CE_N: U2.117 (SLOT_ROM1_CE_N), U12.30 (/CE)
SLOT_SLTSL0_N: J1.4, U1.30 (SLOT_SLTSL0_N)
SLOT_SLTSL1_N: J1.3, U1.32 (SLOT_SLTSL1_N)
SLOT_SLTSL2_N: J1.5, U1.34 (SLOT_SLTSL2_N)
SLOT_SLTSL3_N: J1.6, U1.36 (SLOT_SLTSL3_N)
SLOT_WAIT_N: J2.6, U2.99 (SLOT_WAIT_N)
SLOT_WR_N: J2.12, U2.107 (SLOT_WR_N), U11.7 (/WE), U12.7 (/WE)
SRAM_CS0_N: R15.1, U1.22 (SRAM_CS0_N), U5.1 (~CS)
SRAM_CS1_N: R16.1, U1.24 (SRAM_CS1_N), U6.1 (~CS)
SRAM_CS2_N: R17.1, U1.26 (SRAM_CS2_N), U7.1 (~CS)
SRAM_CS3_N: R18.1, U1.28 (SRAM_CS3_N), U8.1 (~CS)
SRAM_SCLK: R8.2, U1.7 (SRAM_SCLK), U5.6 (SCK), U6.6 (SCK), U7.6 (SCK), U8.6 (SCK)
SRAM_SIO0: R9.2, U1.9 (SRAM_SIO0), U5.5 (SI/SIO0), U6.5 (SI/SIO0), U7.5 (SI/SIO0), U8.5 (SI/SIO0)
SRAM_SIO1: R10.2, U1.11 (SRAM_SIO1), U5.2 (SO/SIO1), U6.2 (SO/SIO1), U7.2 (SO/SIO1), U8.2 (SO/SIO1)
SRAM_SIO2: R11.1, U1.15 (SRAM_SIO2), U5.3 (SIO2), U6.3 (SIO2), U7.3 (SIO2), U8.3 (SIO2)
SRAM_SIO3: R12.1, U1.17 (SRAM_SIO3), U5.7 (~HOLD/SIO3), U6.7 (~HOLD/SIO3), U7.7 (~HOLD/SIO3), U8.7 (~HOLD/SIO3)
SROM_CS_N: R20.1, U2.114 (SROM_CS_N), U10.1 (~CS)
SROM_MISO: R22.1, U2.118 (SROM_MISO), U10.2 (DO/IO_{1})
SROM_MOSI: R21.1, U2.116 (SROM_MOSI), U10.5 (DI/IO_{0})
SROM_SCLK: R19.1, U2.112 (SROM_SCLK), U10.6 (CLK)
UART_RX: J3.5, U2.79 (UART_RX)
UART_TX: J3.7, U2.81 (UART_TX)

File pcb/FPGA_MSXtR_Stack_CPU2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C13, C3, C4, C5, C6, C9",0402,9,0.1uF,C1525
C12,Capacitor(C453487),1,470uF,C76438
C2,0805,1,15pF,C63339
C7,1210,1,100uF,C49066
C8,0402,1,1uF,C2887021
J4,MicroSD(C91145),1,Micro_SD_Card,C91145
J6,USB-C(C2927029),1,USB_C_Receptacle_PowerOnly_6P,C2927029
"R1, R2",0603,2,5.1K,C122969
"R10, R11, R12, R15, R16, R17, R18, R19, R20, R21, R22, R7, R8, R9",0402,14,3.3K,C2906923
"R13, R14",0402,2,100K,C2906859
"R3, R4, R5, R6",0402,4,22K,C2906913
SW1,SideSW (C2906286),1,SW_MEC_5G,C963235
SW2,Slide SW(C7431058),1,SW_SPDT,C7431058
SW3,DipSW4(C129043),1,SW_DIP_x04,C129043
U1,TangPrimer25K(UPPER),1,"The parts have no specific orientation.",C597938
U2,TangPrimer25K(LOWER),1,"The parts have no specific orientation.",C597938
U10,SOIC-8_5.3x5.3mm_P1.27mm,1,W25Q32JVSS,C82344
"U11, U12",TSOP-I-32_18.4x8mm_P0.5mm,2,~,C43651917
U3,CLOCK,1,~,C2901579
"U5, U6, U7, U8",QSPI-SRAM 4Mbit (8SOIC),4,~,C27585175

## KiCad design pcb/FPGA_MSXtR_Stack_SLOT/StackSlot.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11: 0.1uF; C_0402_1005Metric; LCSC C1525
C12: 100uF; C_1210_3225Metric; LCSC C49066
J1, J2: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J5: MSX_EXBUS_B; PinHeader_2x20_P2.54mm_Vertical
J6: MSX_EXBUS_A; PinHeader_2x20_P2.54mm_Vertical
R1, R2, R3: 4.7K; R_0805_2012Metric
R4, R5, R6: 3.3K; R_0805_2012Metric
U1, U2: MSX SLOT
U3, U4, U5, U6, U7: SSOP-24_5.3x8.2mm_P0.65mm; LCSC C19197
U8: SO-14_3.9x8.65mm_P1.27mm

Connections:
3V3: C1.1, C3.1, C5.1, C7.1, C9.1, J5.35, R4.1, R5.1, R6.1, U3.1 (VCCA), U4.1 (VCCA), U4.2 (DIR), U5.1 (VCCA), U5.2 (DIR), U6.1 (VCCA), U6.2 (DIR), U7.1 (VCCA), U7.2 (DIR)
5V: C2.1, C4.1, C6.1, C8.1, C10.1, C11.1, C12.1, J5.39, J6.34, R1.1, R2.1, R3.1, U1.45 (+5V), U1.47 (+5V), U2.45 (+5V), U2.47 (+5V), U3.23 (VCCB), U3.24 (VCCB), U4.23 (VCCB), U4.24 (VCCB), U5.23 (VCCB), U5.24 (VCCB), U6.23 (VCCB), U6.24 (VCCB), U7.23 (VCCB), U7.24 (VCCB), U8.14 (VCC)
+12V: J6.38, U1.48 (+12V), U2.48 (+12V)
-12V: J6.40, U1.50 (-12V), U2.50 (-12V)
A0: U1.28 (A0), U2.28 (A0), U4.16 (B6)
A1: U1.27 (A1), U2.27 (A1), U4.15 (B7)
A2: U1.30 (A2), U2.30 (A2), U4.18 (B4)
A3: U1.29 (A3), U2.29 (A3), U4.17 (B5)
A4: U1.32 (A4), U2.32 (A4), U4.20 (B2)
A5: U1.31 (A5), U2.31 (A5), U4.19 (B3)
A6: U1.22 (A6), U2.22 (A6), U5.18 (B4)
A7: U1.21 (A7), U2.21 (A7), U5.17 (B5)
A8: U1.24 (A8), U2.24 (A8), U5.20 (B2)
A9: U1.17 (A9), U2.17 (A9), U6.21 (B1)
A10: U1.20 (A10), U2.20 (A10), U5.16 (B6)
A11: U1.19 (A11), U2.19 (A11), U5.15 (B7)
A12: U1.23 (A12), U2.23 (A12), U5.19 (B3)
A13: U1.26 (A13), U2.26 (A13), U4.14 (B8)
A14: U1.25 (A14), U2.25 (A14), U5.21 (B1)
A15: U1.18 (A15), U2.18 (A15), U5.14 (B8)
D0: U1.34 (D0), U2.34 (D0), U3.15 (B7)
D1: U1.33 (D1), U2.33 (D1), U3.14 (B8)
D2: U1.36 (D2), U2.36 (D2), U3.17 (B5)
D3: U1.35 (D3), U2.35 (D3), U3.16 (B6)
D4: U1.38 (D4), U2.38 (D4), U3.19 (B3)
D5: U1.37 (D5), U2.37 (D5), U3.18 (B4)
D6: U1.40 (D6), U2.40 (D6), U3.21 (B1)
D7: U1.39 (D7), U2.39 (D7), U3.20 (B2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J5.37, J5.40, J6.36, U1.41 (GND), U1.43 (GND), U2.41 (GND), U2.43 (GND), U3.11 (GND), U3.12 (GND), U3.13 (GND), U4.11 (GND), U4.12 (GND), U4.13 (GND), U5.11 (GND), U5.12 (GND), U5.13 (GND), U6.11 (GND), U6.12 (GND), U6.13 (GND), U7.10 (A8), U7.11 (GND), U7.12 (GND), U7.13 (GND), U8.1 (1A), U8.3 (2A), U8.5 (3A), U8.7 (GND)
SLOT_A0: J6.25, U4.8 (A6)
SLOT_A1: J5.26, U4.9 (A7)
SLOT_A2: J6.27, U4.6 (A4)
SLOT_A3: J5.28, U4.7 (A5)
SLOT_A4: J6.29, U4.4 (A2)
SLOT_A5: J5.30, U4.5 (A3)
SLOT_A6: J6.19, U5.6 (A4)
SLOT_A7: J5.20, U5.7 (A5)
SLOT_A8: J6.21, U5.4 (A2)
SLOT_A9: J5.16, U6.3 (A1)
SLOT_A10: J6.17, U5.8 (A6)
SLOT_A11: J5.18, U5.9 (A7)
SLOT_A12: J5.22, U5.5 (A3)
SLOT_A13: J6.23, U4.10 (A8)
SLOT_A14: J5.24, U5.3 (A1)
SLOT_A15: J6.15, U5.10 (A8)
SLOT_BUSDIR_N: J6.9, R4.2, U8.12 (6Y)
SLOT_CLOCK_N: J6.39, U4.3 (A1)
SLOT_CS1_N: J5.2, U7.4 (A2)
SLOT_CS2_N: J6.1, U7.5 (A3)
SLOT_CS12_N: J5.4, U7.3 (A1)
SLOT_D0: J6.31, U3.9 (A7)
SLOT_D1: J5.32, U3.10 (A8)
SLOT_D2: J6.33, U3.7 (A5)
SLOT_D3: J5.34, U3.8 (A6)
SLOT_D4: J6.35, U3.5 (A3)
SLOT_D5: J5.36, U3.6 (A4)
SLOT_D6: J6.37, U3.3 (A1)
SLOT_D7: J5.38, U3.4 (A2)
SLOT_DATA_DIR: J5.5, U3.2 (DIR)
SLOT_INT_N: J6.7, R6.2, U8.8 (4Y)
SLOT_IORQ_N: J5.10, U6.8 (A6)
SLOT_M1_N: J5.8, U6.9 (A7)
SLOT_MERQ_N: J6.11, U6.7 (A5)
SLOT_OE_N: J5.7, U3.22 (OEn), U4.22 (OEn), U5.22 (OEn), U6.22 (OEn), U7.22 (OEn)
SLOT_RD_N: J6.13, U6.5 (A3)
SLOT_RESET_N: J5.14, U6.4 (A2)
SLOT_RFSH_N: J6.2, U6.10 (A8)
SLOT_SLTSL0_N: J6.4, U7.8 (A6)
SLOT_SLTSL1_N: J6.3, U7.6 (A4)
SLOT_SLTSL2_N: J6.5, U7.7 (A5)
SLOT_SLTSL3_N: J6.6, U7.9 (A7)
SLOT_SNDIN: J5.1, U1.49 (SUNDIN), U2.49 (SUNDIN)
SLOT_WAIT_N: J5.6, R5.2, U8.10 (5Y)
SLOT_WR_N: J5.12, U6.6 (A4)
/BUSDIR: R1.2, U1.10 (/BUSDIR), U2.10 (/BUSDIR), U8.13 (6A)
/CLOCK: U1.42 (CLOCK), U2.42 (CLOCK), U4.21 (B1)
/CS1: U1.1 (/CS1), U2.1 (/CS1), U7.20 (B2)
/CS2: U1.2 (/CS2), U2.2 (/CS2), U7.19 (B3)
/CS12: U1.3 (/CS12), U2.3 (/CS12), U7.21 (B1)
/INT: R3.2, U1.8 (/INT), U2.8 (/INT), U8.9 (4A)
/IORQ: U1.11 (/IORQ), U2.11 (/IORQ), U6.16 (B6)
/M1: U1.9 (/M1), U2.9 (/M1), U6.15 (B7)
/MERQ: U1.12 (/MERQ), U2.12 (/MERQ), U6.17 (B5)
/RD: U1.14 (/RD), U2.14 (/RD), U6.19 (B3)
/RESET: U1.15 (/RESET), U2.15 (/RESET), U6.20 (B2)
/RFSH: U1.6 (/RFSH), U2.6 (/RFSH), U6.14 (B8)
/SLTSL0: J1.1, U7.16 (B6)
/SLTSL1: U1.4 (/SLTSL), U7.18 (B4)
/SLTSL2: U2.4 (/SLTSL), U7.17 (B5)
/SLTSL3: J2.1, U7.15 (B7)
/WAIT: R2.2, U1.7 (/WAIT), U2.7 (/WAIT), U8.11 (5A)
/WR: U1.13 (/WR), U2.13 (/WR), U6.18 (B4)

Notes on the sheet:
SN74LVC8T245DBR 24SSOP
ラズパイ用スタッキングコネクターが使える
BUSDIR 0: CPU → Cartridge (WRITE) 1: CPU ← Cartridge (READ)
SLOT1
SLOT2

Board: 2 copper layers, 95.0 x 95.0 mm, 32 parts (0 on the bottom side), 92 nets.

Other parts of the board:
G1: LOGO; msx_logo
G2: LOGO; usa

## KiCad design pcb/FPGA_MSXtR_Stack_Y8960/StackY8960.kicad_pcb

Board: 2 copper layers, 158.2 x 98.5 mm, 34 parts (0 on the bottom side), 64 nets, no tracks yet.

Parts:
C1, C2: 0.1uF; C_0402_1005Metric
C3: 15pF; C_0805_2012Metric
C4: 100uF; C_1210_3225Metric
D1, D2, D3, D4: LED; LED_0805_2012Metric
J1: MSX_EXBUS_A; PinHeader_2x20_P2.54mm_Vertical
J2: MSX_EXBUS_B; PinHeader_2x20_P2.54mm_Vertical
J3: I2S_CONN; PinHeader_1x06_P2.54mm_Vertical
J4: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J5: GND; PinHeader_1x01_P2.54mm_Vertical
J6: SOUNDIN; PinHeader_1x01_P2.54mm_Vertical
R9, R10, R11, R12: 3.3k; R_0805_2012Metric
R13, R14, R15, R16, R17, R18: 4.7k; R_0805_2012Metric
R24, R25, R26, R27: 470; R_0805_2012Metric
SW1, SW2: SlideSW_Side
U1: TangPrimer25K(UPPER)
U2: TangPrimer25K(LOWER)
U3: QSPI-SRAM 4Mbit (8SOIC)
U4: CLOCK

Connections:
5V: C4.1, J1.34, J2.39, J4.4, U1.52 (VDD_5V), U1.54 (VDD_5V), U1.56 (VDD_5V), U1.58 (VDD_5V), U1.60 (VDD_5V)
+3V3: C1.1, C2.1, J3.6, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.2, R18.2, R24.1, R25.1, R26.1, R27.1, U1.2 (VCCIO2/3), U1.4 (VCCIO2/3), U1.46 (VDD_3V3), U1.48 (VDD_3V3), U1.50 (VDD_3V3), U2.84 (VCCIO0/1), U2.86 (VCCIO0/1), U2.89 (VCCIO6/7), U2.91 (VCCIO6/7), U3.8 (VCC), U4.1 (En), U4.4 (3V3)
AUDIO_BCLK: J3.2, R10.2, U2.114 (AUDIO_BCLK)
AUDIO_LRCLK: J3.4, R11.2, U2.116 (AUDIO_LRCLK)
AUDIO_MCLK: J3.1, R9.2, U2.112 (AUDIO_MCLK)
AUDIO_SDATA: J3.3, R12.2, U2.118 (AUDIO_SDATA)
CLK28M: C3.1, U2.64 (CLK28M), U4.3 (CLK)
DIPSW0: SW1.2, U2.77 (DIPSW0(READY))
DIPSW1: SW2.2, U2.83 (DIPSW1)
GND: C1.2, C2.2, C3.2, C4.2, J1.36, J2.37, J2.40, J3.5, J4.1, J4.2, J5.1, SW1.1, SW2.1, U1.1 (GND), U1.19 (GND), U1.29 (GND), U1.35 (GND), U1.41 (GND), U1.47 (GND), U1.53 (GND), U1.59 (GND), U2.61 (GND), U2.62 (GND), U2.75 (GND), U2.87 (GND), U2.88 (GND), U2.105 (GND), U2.110 (GND), U2.119 (GND), U2.120 (GND), U3.4 (VSS), U4.2 (GND)
JTAG_TCK: J4.6, U1.21 (JTAG_TCK)
JTAG_TDI: J4.8, U1.27 (JTAG_TDI)
JTAG_TDO: J4.10, U1.25 (JTAG_TDO)
JTAG_TMS: J4.12, U1.23 (JTAG_TMS)
unnamed: D1.2 (A), R24.2
unnamed: D1.1 (K), U2.111 (LED0)
unnamed: D2.2 (A), R25.2
unnamed: D2.1 (K), U2.113 (LED1)
unnamed: D3.2 (A), R26.2
unnamed: D3.1 (K), U2.115 (LED2)
unnamed: D4.2 (A), R27.2
unnamed: D4.1 (K), U2.117 (LED3)
SLOT_A0: J1.25, U2.63 (SLOT_A0)
SLOT_A1: J2.26, U2.65 (SLOT_A1)
SLOT_A2: J1.27, U2.67 (SLOT_A2)
SLOT_A3: J2.28, U2.69 (SLOT_A3)
SLOT_A4: J1.29, U2.71 (SLOT_A4)
SLOT_A5: J2.30, U2.73 (SLOT_A5)
SLOT_A6: J1.19, U2.93 (SLOT_A6)
SLOT_A7: J2.20, U2.95 (SLOT_A7)
SLOT_A8: J1.21, U2.82 (SLOT_A8)
SLOT_A9: J2.16, U2.80 (SLOT_A9)
SLOT_A10: J1.17, U2.78 (SLOT_A10)
SLOT_A11: J2.18, U2.76 (SLOT_A11)
SLOT_A12: J2.22, U2.74 (SLOT_A12)
SLOT_A13: J1.23, U2.72 (SLOT_A13)
SLOT_A14: J2.24, U2.108 (SLOT_A14)
SLOT_A15: J1.15, U2.106 (SLOT_A15)
SLOT_D0: J1.31, U2.90 (SLOT_D0)
SLOT_D1: J2.32, U2.92 (SLOT_D1)
SLOT_D2: J1.33, U2.94 (SLOT_D2)
SLOT_D3: J2.34, U2.96 (SLOT_D3)
SLOT_D4: J1.35, U2.98 (SLOT_D4)
SLOT_D5: J2.36, U2.100 (SLOT_D5)
SLOT_D6: J1.37, U2.102 (SLOT_D6)
SLOT_D7: J2.38, U2.104 (SLOT_D7)
SLOT_INT_N: J1.7, U2.97 (SLOT_INTR)
SLOT_IORQ_N: J2.10, U2.68 (SLOT_IORQ_N)
SLOT_M1_N: J2.8, U1.6 (SLOT_M1_N)
SLOT_MERQ_N: J1.11, U2.70 (SLOT_MERQ_N)
SLOT_RD_N: J1.13, U2.109 (SLOT_RD_N)
SLOT_RESET_N: J2.14, U2.101 (SLOT_RESET_N)
SLOT_SLTSL0_N: J1.4, U2.66 (SLOT_SLTSL_N)
SLOT_SNDIN: J2.1, J6.1
SLOT_WAIT_N: J2.6, U2.99 (SLOT_WAIT)
SLOT_WR_N: J2.12, U2.107 (SLOT_WR_N)
SRAM_CS_N: R13.2, U1.9 (SRAM_CS_N), U3.1 (~CS)
SRAM_SCLK: R14.2, U1.7 (SRAM_SCLK), U3.6 (SCK)
SRAM_SIO0: R15.2, U1.11 (SRAM_SIO0), U3.5 (SI/SIO0)
SRAM_SIO1: R16.2, U1.5 (SRAM_SIO1), U3.2 (SO/SIO1)
SRAM_SIO2: R17.1, U1.15 (SRAM_SIO2), U3.3 (SIO2)
SRAM_SIO3: R18.1, U1.17 (SRAM_SIO3), U3.7 (~HOLD/SIO3)
UART_RX: J4.5, U2.79 (UART_RX)
UART_TX: J4.7, U2.81 (UART_TX)

## KiCad design pcb/FPGA_MSXtR_Stack_V9968/StackV9968.kicad_pcb

Parts:
C1: 100uF; C_1210_3225Metric; LCSC C49066
C2: 0.1uF; C_0402_1005Metric; LCSC C1525
C3: 15pF; C_0805_2012Metric; LCSC C63339
J1: MSX_EXBUS_A; PinHeader_2x20_P2.54mm_Vertical
J2: MSX_EXBUS_B; PinHeader_2x20_P2.54mm_Vertical
SW1, SW2: SlideSW_Side
U1: CLOCK; LCSC C2901579
U2: TangNano20K

Connections:
3V3: J2.35
5V: C1.1, J1.34, J2.39, U2.40 (5V)
+12V: J1.38
-12V: J1.40
CLOCK: C3.1, U1.3 (CLK), U2.37 (IOT27A(80):SDIO_D2)
DIPSW0: SW1.2, U2.22 (IOR38B(53))
DIPSW1: SW2.2, U2.21 (IOR39A(52))
GND: C1.2, C2.2, C3.2, J1.36, J2.37, J2.40, SW1.3, SW2.3, U1.2 (GND), U2.20 (GND), U2.26 (GND), U2.39 (GND)
I2S_BCLK: J1.8, U2.34 (IOR36A(56))
I2S_DIN: J1.10, U2.33 (IOR38A(54))
I2S_EN: J1.12, U2.32 (IOR45A(51))
I2S_LRCK: J1.14, U2.30 (IOR36B(55))
SLOT_A0: J1.25, U2.13 (IOB14B(30))
SLOT_A1: J2.26, U2.14 (IOB29A(31))
SLOT_A2: J1.27, U2.38 (IOT30B(76))
SLOT_A3: J2.28, U2.36 (IOB42B(42))
SLOT_A4: J1.29, U2.35 (IOB43A(41))
SLOT_A5: J2.30, U2.31 (IOR49B(48))
SLOT_A6: J1.19, U2.29 (IOR49A(49))
SLOT_A7: J2.20, U2.15 (IOL49A(17))
SLOT_A8: J1.21
SLOT_A9: J2.16
SLOT_A10: J1.17
SLOT_A11: J2.18
SLOT_A12: J2.22
SLOT_A13: J1.23
SLOT_A14: J2.24
SLOT_A15: J1.15
SLOT_BUSDIR_N: J1.9
SLOT_CLOCK_N: J1.39
SLOT_CS1_N: J2.2
SLOT_CS2_N: J1.1
SLOT_CS12_N: J2.4
SLOT_D0: J1.31, U2.12 (IOB14A(29))
SLOT_D1: J2.32, U2.9 (IOB8B(28))
SLOT_D2: J1.33, U2.8 (IOB8A(27))
SLOT_D3: J2.34, U2.5 (IOT30A(77))
SLOT_D4: J1.35, U2.4 (IOT4B(85):SDIO_D1)
SLOT_D5: J2.36, U2.3 (IOT34A(75))
SLOT_D6: J1.37, U2.2 (IOT34B(74))
SLOT_D7: J2.38, U2.1 (IOT40A(73))
SLOT_DATA_DIR: J2.5
SLOT_INT_N: J1.7, U2.23 (IOT44A(71))
SLOT_IORQ_N: J2.10, U2.18 (IOL49B(18))
SLOT_M1_N: J2.8
SLOT_MERQ_N: J1.11
SLOT_OE_N: J2.7
SLOT_RD_N: J1.13, U2.6 (IOL47A(15))
SLOT_RESET_N: J2.14, U2.28 (IOT4A(86))
SLOT_RFSH_N: J1.2
SLOT_SLTSL0_N: J1.4
SLOT_SLTSL1_N: J1.3
SLOT_SLTSL2_N: J1.5
SLOT_SLTSL3_N: J1.6
SLOT_SNDIN: J2.1
SLOT_WAIT_N: J2.6, U2.24 (IOT40B(72))
SLOT_WR_N: J2.12, U2.7 (IOT47B(16))
VDP_3V3: C2.1, SW1.1, SW2.1, U1.4 (3V3), U2.19 (3V3), U2.25 (3V3)

Notes on the sheet:
ラズパイ用スタッキングコネクターが使える
En は、OPEN か H で CLK を出力、L で CLK が HiZ になる。
TangNano20K
14.318180MHz

Notices in the files:
pcb/FPGA_MSXtR_Portable_Keyboard/FPGA_MSXtR_Portable_Keyboard.kicad_pcb:
Copyright 2026 HRA!
pcb/FPGA_MSXtR_Stack_CPU2/StackCPU.kicad_pcb:
Copyright (C)2026 HRA!
